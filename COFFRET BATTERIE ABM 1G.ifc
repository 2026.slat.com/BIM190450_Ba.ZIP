Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2019-06-18T11:45:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 18 11:45:11 2019 * Host: Piranha * Database: C:\Users\datBIM\AppData\Local\Temp\{F996A67E-83A7-4F74-8201-E0C960447063}\ifc * Database version: 5507 * Database creation date: Tue Jun 18 11:45:08 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 18 11:45:09 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 18 11:45:09 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: COFFRET BATTERIE ABM 1G, COFFRET BATTERIE ABM 1G:COFFRET BATTERIE ABM 1G:137877
In: Niveau 1
Type - Autre - Catégorie: Equipement électrique; datBIM.Code datBIM entité: 9069002012; datBIM.Code produit SLAT (Id SlatEntityCode): 9069002012; datBIM.Conformite ATEX (ATEX compliance): Non (No); datBIM.Couleur dominante (Dominant color): Gris RAL 7035 (Grey RAL 7035); datBIM.Description longue entité: <p> <img title="ABM 1G.JPG" src="https://admin.datbim.com/media/mid/1/23319.jpg" alt="" width="244" height="235" data-idmedia="23319" /></p><p><em>Ref. : 9069002012<br /></em></p><p>Secours électrique / Electrical backup.</p>; datBIM.Designation technique (Technical designation): COFFRET BATTERIE ABM 1G; datBIM.Duree de la garantie (Length of warranty): 1 an; datBIM.Duree de vie previsionnelle (Expected life expectancy): 10 ans; datBIM.Fonction generique (Generic function): Coffret batterie (Battery box); datBIM.Hauteur (Height): 610 mm; datBIM.Hauteur hors tout (Height overall): 617.5 mm; datBIM.Id: datBIM:384188; datBIM.Largeur (Wide): 505 mm; datBIM.Largeur hors tout (Wide overall): 509 mm; datBIM.Libellé entité: COFFRET BATTERIE ABM 1G; datBIM.Longueur (Length): 430 mm; datBIM.Longueur hors tout (Length overall): 430 mm; datBIM.Marque commerciale (Commercial brand): SLAT; datBIM.Matiere de l'enveloppe (Envelope material): Acier (Steel); datBIM.Poids (Weight): 16; datBIM.Produit repartis dans plusieurs enveloppes (Product divided into several envelopes): Non (No); datBIM.Qualification d'installateur : NF S 61-932 - Règles d’installation (Installer qualification : NF S 61-932 - Installation rules): Recommandé (Recommanded); datBIM.Qualification d'installateur : NF S 61-970 - Règles d'installation des systèmes de détection incendie (Installer qualification : Installation rules for fire detection systems): Recommandé (Recommanded); datBIM.Qualification d'installateur : R7 (Installer qualification : R7): Recommandé (Recommanded); datBIM.Qualification du mainteneur : Annexe B NF S 61-933 - SDI (Qualification of the maintainer : Appendix B NF S 61-933 - SDI): Recommandé (Recommanded); datBIM.Qualification du mainteneur : Annexe J NF S 61-933 Alimentation (Qualification of the maintainer : Appendix J NF S 61-933 Power supply): Recommandé (Recommanded); datBIM.Qualification du mainteneur : Annexe L NF S 61-933 Exploitant (Qualification of the maintainer : Appendix L NF S 61-933 Operator): Recommandé (Recommanded); datBIM.Site WEB du fournisseur: www.slat.com; datBIM.Substance visee par REACH_DEEE (Substance covered by REACH_DEEE): Non (No); datBIM.Type de liaison (Type of link): Filaire (Wired); datBIM.Type d'installation (Mounting type): A poser (Floor-mounted); Nom de la famille: COFFRET BATTERIE ABM 1G
Type - Données d'identification - Fabricant: SLAT; Nom du type: COFFRET BATTERIE ABM 1G
Pset_BuildingElementProxyCommon - Reference: COFFRET BATTERIE ABM 1G
Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Autre - Famille: COFFRET BATTERIE ABM 1G: COFFRET BATTERIE ABM 1G; Famille et type: COFFRET BATTERIE ABM 1G: COFFRET BATTERIE ABM 1G; ID du type: COFFRET BATTERIE ABM 1G: COFFRET BATTERIE ABM 1G; Type: COFFRET BATTERIE ABM 1G: COFFRET BATTERIE ABM 1G
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.78289 m2; Volume: 0.132252 m3
Données d'identification - Identifiant: 1
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Phase 1
